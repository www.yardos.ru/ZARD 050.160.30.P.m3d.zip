# KOMPAS-3D part (ZARD 050.160.30.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ООО ИК Энерпред-Ярдос